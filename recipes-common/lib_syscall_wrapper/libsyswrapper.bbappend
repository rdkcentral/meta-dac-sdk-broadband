EXTRA_OECONF:remove = "--disable-static "
