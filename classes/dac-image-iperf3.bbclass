SUMMARY = "Base class for DAC Images with SDL support"

inherit  dac-image-base

#IMAGE_INSTALL:append = " libsdl2"
